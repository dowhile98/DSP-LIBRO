# Keil uVision project cap2_ejercicio_2_2.uvprojx, settings and files
target CORTEX-M4 (6140000::V6.14::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cap2_ejercicio_2_2
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000
  c include: C:\Users\Lenovo\STM32Cube\Repository\STM32Cube_FW_F4_V1.25.2\Drivers\BSP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c hal_config.h
    C:/Users/Lenovo/STM32Cube/Repository/STM32Cube_FW_F4_V1.25.2/Drivers/BSP/Components/lis3dsh/: lis3dsh.c
    C:/Users/Lenovo/STM32Cube/Repository/STM32Cube_FW_F4_V1.25.2/Drivers/BSP/Components/lis302dl/: lis302dl.c
    C:/Users/Lenovo/STM32Cube/Repository/STM32Cube_FW_F4_V1.25.2/Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_accelerometer.c
software components: CMSIS:CORE 5.4.0, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:I2C 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:SPI 1.7.6, Device:Startup 2.6.3
