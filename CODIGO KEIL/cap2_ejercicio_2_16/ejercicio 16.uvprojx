# Keil uVision project ejercicio 16.uvprojx, settings and files
target DPS AMR CORTEX -M4 (6140000::V6.14::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ejercicio 16
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __FPU_PRESENT = 1, ARM_MATH_CM4, HSE_VALUE=8000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c time.h FIR_lpf_coefficients.h FIR_hpf_coefficients.h
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Device:Startup 2.6.3
